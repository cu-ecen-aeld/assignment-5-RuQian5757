## base_external/Config.in
```kconfig
config BR2_PACKAGE_AESD_ASSIGNMENTS
    bool "aesd-assignments"
    help
      AESD assignments package, includes writer, finder.sh, and tester.sh
```
